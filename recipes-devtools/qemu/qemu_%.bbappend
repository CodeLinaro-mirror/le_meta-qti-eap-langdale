PACKAGECONFIG_class-native:append = " libusb"
