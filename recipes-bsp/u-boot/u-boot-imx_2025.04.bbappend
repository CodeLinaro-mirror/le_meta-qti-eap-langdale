FILESEXTRAPATHS:prepend := "${THISDIR}/files:"

SRC_URI += " \
    file://0001-u-boot-imx-disable-PCIe-driver-probe-support.patch \
"
