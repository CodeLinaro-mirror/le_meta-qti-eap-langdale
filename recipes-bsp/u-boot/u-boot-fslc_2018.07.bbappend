FILESEXTRAPATHS_prepend := "${THISDIR}/${PN}:"

SRC_URI += "file://Use-usdhc4-for-imx6sxsabresd.patch"
